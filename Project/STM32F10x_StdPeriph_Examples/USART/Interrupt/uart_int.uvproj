# Keil uVision project uart_int.uvproj, settings and files
target uart_int (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uart_int
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Interrupt
  asm define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./: startup_stm32f10x_hd.s main.c platform_config.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.c stm32f10x_it.c
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group lib
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
