# Keil uVision project spi.uvproj, settings and files
target spi (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: spi
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FullDuplex_SoftNSS;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  asm define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./: startup_stm32f10x_hd.s main.c stm32f10x_it.c system_stm32f10x.c platform_config.h stm32f10x_conf.h stm32f10x_it.h
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group lib
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_gpio.c
